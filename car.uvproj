# Keil uVision project car.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: car +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c head.h move.c tools.c pwm.c AI-speed.c digital-tube.c bluetooth.c power.c ultrasound.c oled.c character.h data_init.c
